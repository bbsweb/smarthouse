# Keil uVision project smarthouse.uvprojx, settings and files
target smarthouse (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smarthouse +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\CMSIS;.\CMSIS\startup;.\FWlib\inc;.\FWlib\src;.\User;.\User\LED;.\User\SysTick;.\User\USART;.\User\esp8266;.\User\DHT11;.\User\TLINK;.\User\TIM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./CMSIS/startup/: startup_stm32f10x_md.s
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Drivers
    ./User/LED/: led.c
    ./User/SysTick/: SysTick.c
    ./User/USART/: usart.c
    ./User/TLINK/: TLINK.c
    ./User/TIM/: Tim.c
    ./User/esp8266/: esp8266.c
  group User
    ./User/: main.c stm32f10x_it.c
